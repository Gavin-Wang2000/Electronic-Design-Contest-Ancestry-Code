# Keil uVision project Msp432.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Msp432
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..\Lib\driverlib\MSP432P4xx;..\Lib\inc;..\Lib\inc\CMSIS;..\Hardware\delay;..\Hardware\key;..\Hardware\led;..\Hardware\motor;..\Hardware\oled;..\Hardware\servo;..\Hardware\system;..\Hardware\encoder;..\Hardware\timer;..\Hardware\control;..\Hardware\openmv;..\Hardware\pid;..\Hardware\zigbee;..\Hardware\sensor;..\Hardware\menu;..\Hardware\buzzer;..\User;..\Hardware\ADC;..\Hardware\MPU6050;..\Hardware\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ./: main.c main.h
  group Lib
    ../Lib/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group Startup
    ./RTE/Device/MSP432P401R/: startup_msp432p401r_uvision.s system_msp432p401r.c
  group Hardware
    ../Hardware/delay/: delay.c
    ../Hardware/key/: Key.c
    ../Hardware/led/: led.c
    ../Hardware/motor/: motor.c
    ../Hardware/oled/: oled.c
    ../Hardware/system/: system.c
    ../Hardware/encoder/: encoder.c
    ../Hardware/timer/: timer.c
    ../Hardware/control/: control.c
    ../Hardware/openmv/: openmv.c
    ../Hardware/zigbee/: zigbee.c
    ../Hardware/sensor/: sensor.c
    ../Hardware/menu/: menu.c
    ../Hardware/buzzer/: buzzer.c
    ../Hardware/ADC/: adc.c
    ../Hardware/MPU6050/: mpu6050.c mpuI2C.c mpuexit.c
    ../Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
