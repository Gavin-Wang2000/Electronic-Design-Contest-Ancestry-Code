# Keil uVision project TM4C123G.uvproj, settings and files
target TIVA (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: TM4C123GH6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TM4C123G +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\..\User;..\..\Hardware\led;..\..\Hardware\oled;..\..\Hardware\key;..\..\Hardware\timer;..\..\Hardware\openmv;..\..\Hardware\motor;..\..\Hardware\encoder;..\..\Hardware\mpu6050;..\..\Hardware\MPU6050;..\..\Hardware\MPU6050\eMPL;..\..\Hardware\eeprom;..\..\Hardware\control;..\..\Libraries\driverlib;..\..\Libraries\inc;..\..\Libraries\utils
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libraries
    ../../Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group User
    ../../User/: main.c startup_rvmdk.S sys.c delay.c
    ../../Libraries/utils/: uartstdio.c
  group Hardware
    ../../Hardware/led/: led.c
    ../../Hardware/oled/: oled.c
    ../../Hardware/key/: key.c
    ../../Hardware/timer/: myTimer.c
    ../../Hardware/openmv/: openmv.c
    ../../Hardware/motor/: motor.c
    ../../Hardware/encoder/: encoder.c
    ../../Hardware/MPU6050/: 6050.c driver_iic.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpuExit.c
    ../../Hardware/eeprom/: myeeprom.c
    ../../Hardware/control/: control.c
